File: PCB/S23_DB.kicad_sch (KiCad schematic)
At the start: 8 parts, among them J1 JST

Commit message: Update sheets
Other:
- company: Cipulot PCB Design -> LU.SV Solutions
